File: PCB/flash.kicad_sch (KiCad schematic)
At the start: 5 parts, among them SW1 Reset, U10 W25Q16JVZP

Commit message: ok
Other:
- moved on the sheet: C13, C15, R18, SW1, U10
